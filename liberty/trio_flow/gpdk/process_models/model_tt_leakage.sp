*** Model include file ***

simulator lang = spectre
include "models/spectre/gpdk045.scs" section=tt
simulator lang = spice
